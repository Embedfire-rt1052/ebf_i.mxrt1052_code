# Keil uVision project YH-RT1052.uvprojx, settings and files
target itcm_txt_ram_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM7,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6B
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\libraries\sdmmc\inc;..\..\libraries\sdmmc\port;..\..\libraries\fatfs\fsl_sd_disk;..\..\libraries\fatfs;..\..\user\bsp\sai;..\..\user\bsp\codec;..\..\user\bsp\codec\wm8960
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_itcm_txt_ram.scf
  group CMSIS
    ../../libraries/: system_MIMXRT1052.c system_MIMXRT1052.h
    ../../libraries/CMSIS/Lib/ARM/: arm_cortexM7lfsp_math.lib
  group startup
    ./: startup_MIMXRT1052.s
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_iomuxc.h fsl_usdhc.c fsl_cache.c fsl_sai.c fsl_sai_edma.c fsl_edma.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_dmamux.c
    ../../user/bsp/codec/: fsl_codec_common.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_shell.c fsl_sbrk.c fsl_debug_console.c
    ../../libraries/utilities/str/: fsl_str.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/io/: fsl_io.c
  group board
    ../../user/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group user
    ../../user/: main.c
    ../../user/bsp/led/: bsp_led.c
    ../../user/bsp/sd/: bsp_sd.c
    ../../user/bsp/sd_fatfs_test/: bsp_sd_fatfs_test.c
    ../../user/bsp/sai/: sai.c recordPlayback.c
    ../../user/bsp/codec/wm8960/: fsl_wm8960.c
  group xip
    ../../user/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
  group doc
    ../../doc/: 必读说明.txt
  group sdmmc
    ../../libraries/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../../libraries/sdmmc/port/usdhc/polling/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group fatfs
    ../../libraries/fatfs/fsl_sd_disk/: fsl_sd_disk.c
    ../../libraries/fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
target itcm_txt_sdram_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6B,ARM_MATH_CM7
  c misc: as above
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\libraries\sdmmc\inc;..\..\libraries\sdmmc\port;..\..\libraries\fatfs;..\..\libraries\fatfs\fsl_sd_disk;..\..\user\bsp\codec\wm8960;..\..\user\bsp\sai;..\..\user\bsp\codec
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_itcm_txt_sdram.scf
target sdram_txt_ram_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6B, ARM_MATH_CM7
  c misc: as above
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\libraries\sdmmc\inc;..\..\libraries\sdmmc\port;..\..\libraries\fatfs\fsl_sd_disk;..\..\libraries\fatfs;..\..\user\bsp\codec\wm8960;..\..\user\bsp\sai;..\..\user\bsp\codec
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_sdram_txt_ram.scf
target nor_txt_ram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,USE_RAM_VECTOR_TABLE,ARM_MATH_CM7,SDK_I2C_BASED_COMPONENT_USED,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SKIP_SYSCLK_INIT, DEBUG, ARM_MATH_CM7, ARM_MATH_CM4, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1
  c misc: as above
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user\bsp;..\..\libraries\sdmmc\inc;..\..\libraries\sdmmc\port;..\..\libraries\fatfs;..\..\libraries\fatfs\fsl_sd_disk;..\..\user\bsp\sai;..\..\user\bsp\codec;..\..\user\bsp\codec\wm8960;..\..\libraries\CMSIS\Include;..\..\user;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Lib\ARM
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_txt_ram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
target nor_txt_sdram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1,CPU_MIMXRT1052CVL5B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,USE_RAM_VECTOR_TABLE, ARM_MATH_CM7
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_txt_sdram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
target nor_itcm_txt_ram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,USE_RAM_VECTOR_TABLE, ARM_MATH_CM7
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_itcm_txt_ram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
target nor_sdram_txt_sdram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_sdram_txt_sdram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)

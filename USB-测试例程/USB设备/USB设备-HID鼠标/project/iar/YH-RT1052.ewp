# IAR project YH-RT1052.ewp, settings and files
configuration itcm_txt_ram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1052CVL5B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SDRAM_IS_SHAREABLE; SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1052DVL6B; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\libraries; ..\..\libraries\CMSIS\Include; ..\..\libraries\drivers; ..\..\libraries\utilities; ..\..\libraries\utilities\str; ..\..\libraries\utilities\log; ..\..\libraries\utilities\io; ..\..\libraries\xip; ..\..\user; ..\..\user\bsp; ..\..\libraries\USB\usb_middleware\phy; ..\..\libraries\USB\usb_middleware\osa; ..\..\libraries\USB\usb_middleware\include; ..\..\libraries\USB\usb_middleware\host; ..\..\libraries\USB\usb_middleware\device; ..\..\libraries\USB; ..\..\user\bsp\driver_mouse
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: YH-RT1052.srec
  ILINK.IlinkOutputFile: YH-RT1052.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_itcm_txt_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration itcm_txt_sdram_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_itcm_txt_sdram.icf
configuration sdram_txt_ram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCIncludePath2: ..\..\libraries; ..\..\libraries\CMSIS\Include; ..\..\libraries\drivers; ..\..\libraries\utilities; ..\..\libraries\utilities\str; ..\..\libraries\utilities\log; ..\..\libraries\utilities\io; ..\..\libraries\xip; ..\..\user; ..\..\user\bsp
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram_txt_ram.icf
configuration nor_txt_ram (ARM)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_txt_ram.icf
configuration nor_txt_sdram (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_txt_sdram.icf
configuration nor_itcm_txt_ram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1052CVL5B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; USE_RAM_VECTOR_TABLE; SDRAM_IS_SHAREABLE; SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1052DVL6B; USB_STACK_BM; USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_itcm_txt_ram .icf
configuration nor_sdram_txt_sdram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1052CVL5B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; USE_RAM_VECTOR_TABLE; SDRAM_IS_SHAREABLE; SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1052DVL6B; USB_STACK_BM
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_sdram_txt_sdram.icf
  group board
    ../../user/: board.c clock_config.c pin_mux.c
  group CMSIS
    ../../libraries/: system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    ../../doc/: 必读说明.txt
  group drivers
    ../../libraries/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_gpio.c fsl_iomuxc.h fsl_lpuart.c
  group startup
    ./: startup_MIMXRT1052.s startup_MIMXRT1052_ram_vector.s
  group USB/osa
    ../../libraries/USB/usb_middleware/osa/: usb_osa_bm.c
  group USB/usb-device-class
    ../../libraries/USB/: usb_device_class.c
  group USB/usb-device-class-hid
    ../../libraries/USB/: usb_device_hid.c
  group USB/usb-device-include
    ../../libraries/USB/usb_middleware/device/: usb_device.h
  group USB/usb-device-source
    ../../libraries/USB/: usb_device_ch9.c
    ../../libraries/USB/usb_middleware/device/: usb_device_dci.c
  group USB/usb-device-source-ehci
    ../../libraries/USB/usb_middleware/device/: usb_device_ehci.c
  group USB/usb-include
    ../../libraries/USB/usb_middleware/include/: usb.h usb_misc.h usb_spec.h
  group USB/usb-phy
    ../../libraries/USB/usb_middleware/phy/: usb_phy.c
  group user
    ../../user/bsp/driver_mouse/: bsp_driver_mouse.c
    ../../user/bsp/led/: bsp_led.c
    ../../user/: main.c
    ../../libraries/USB/: usb_device_descriptor.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_sbrk.c fsl_shell.c
    ../../libraries/utilities/io/: fsl_io.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/str/: fsl_str.c
  group xip
    ../../user/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c

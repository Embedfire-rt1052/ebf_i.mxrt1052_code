# IAR project YH-RT1052.ewp, settings and files
configuration itcm_txt_ram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS; USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\libraries; ..\..\libraries\CMSIS\Include; ..\..\libraries\drivers; ..\..\libraries\utilities; ..\..\libraries\utilities\str; ..\..\libraries\utilities\log; ..\..\libraries\utilities\io; ..\..\libraries\xip; ..\..\user; ..\..\user\bsp; ..\..\FreeRTOS\include; ..\..\FreeRTOS\port\IAR\ARM_CM7\r0p1; ..\..\libraries\USB\usb_middleware\phy; ..\..\libraries\USB\usb_middleware\osa; ..\..\libraries\USB\usb_middleware\include; ..\..\libraries\USB\usb_middleware\host; ..\..\libraries\USB\usb_middleware\device; ..\..\libraries\USB; ..\..\user\bsp\driver_mouse; ..\..\user\bsp\led
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..\..\user
  OBJCOPY.OOCOutputFile: YH-RT1052.srec
  ILINK.IlinkOutputFile: YH-RT1052.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_itcm_txt_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration itcm_txt_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS; USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_itcm_txt_sdram.icf
configuration sdram_txt_ram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram_txt_ram.icf
configuration nor_txt_ram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_txt_ram.icf
configuration nor_txt_sdram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS; USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_txt_sdram.icf
configuration nor_itcm_txt_ram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; USE_RAM_VECTOR_TABLE; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS; USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_itcm_txt_ram .icf
configuration nor_sdram_txt_sdram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_sdram_txt_sdram.icf
  group board
    ../../user/: board.c clock_config.c pin_mux.c
  group CMSIS
    ../../libraries/: system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    ../../doc/: 必读说明.txt
  group drivers
    ../../libraries/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_gpio.c fsl_iomuxc.h fsl_lpuart.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group startup
    ./: startup_MIMXRT1052.s startup_MIMXRT1052_ram_vector.s
  group USB/osa
    ../../libraries/USB/usb_middleware/osa/: usb_osa.h usb_osa_freertos.c usb_osa_freertos.h
  group USB/usb-device-class
    ../../libraries/USB/: usb_device_class.c
  group USB/usb-device-class-video
    ../../libraries/USB/: usb_device_video.c
  group USB/usb-device-include
    ../../libraries/USB/usb_middleware/device/: usb_device.h
  group USB/usb-device-source
    ../../libraries/USB/: usb_device_ch9.c
    ../../libraries/USB/usb_middleware/device/: usb_device_dci.c
  group USB/usb-device-source-ehci
    ../../libraries/USB/usb_middleware/device/: usb_device_ehci.c
  group USB/usb-include
    ../../libraries/USB/usb_middleware/include/: usb.h usb_misc.h usb_spec.h
  group USB/usb-phy
    ../../libraries/USB/usb_middleware/phy/: usb_phy.c
  group user
    ../../user/bsp/driver_mouse/: bsp_driver_virtual_camera.c
    ../../user/bsp/key/: bsp_key.c
    ../../user/bsp/led/: bsp_led.c
    ../../user/bsp/systick/: bsp_systick.c
    ../../user/bsp/delay/: core_delay.c
    ../../user/: FreeRTOSConfig.h main.c
    ../../libraries/USB/: usb_device_descriptor.c video_data.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_sbrk.c fsl_shell.c
    ../../libraries/utilities/io/: fsl_io.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/str/: fsl_str.c
  group xip
    ../../user/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c

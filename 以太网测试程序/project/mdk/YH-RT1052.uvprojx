# Keil uVision project YH-RT1052.uvprojx, settings and files
target lcd_sdram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,SKIP_SYSCLK_INIT,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_sdram.scf
  group CMSIS
    ../../libraries/: system_MIMXRT1052.c system_MIMXRT1052.h
  group startup
    ./: startup_MIMXRT1052.s
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_iomuxc.h fsl_elcdif.c fsl_lpi2c.c fsl_flexspi.c fsl_usdhc.c fsl_enet.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_shell.c fsl_sbrk.c fsl_debug_console.c
    ../../libraries/utilities/str/: fsl_str.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/io/: fsl_io.c
  group board
    ../../user/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h fsl_phy.c
  group user
    ../../user/delay/: core_delay.c
    ../../user/: main.c sdram_test.c
    ../../user/bsp/led/: bsp_led.c
    ../../user/bsp/lcd/: bsp_lcd.c
    ../../user/bsp/font/: fonts.c
    ../../user/bsp/touch/: bsp_i2c_touch.c gt9xx.c palette.c
    ../../user/bsp/eeprom/: bsp_i2c_eeprom.c eeprom_test.c
    ../../user/bsp/norflash/: bsp_norflash.c norflash_test.c
    ../../user/bsp/logictest/: logictest.c
    ../../user/bsp/sdcard/: sdcard_test.c
    ../../user/bsp/lwip/test/: lwip_ping_test.c
  group xip
    ../../user/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
  group doc
    ../../doc/: 必读说明.txt
  group sdcard
    ../../user/bsp/sdcard/port/usdhc/polling/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../user/bsp/sdcard/src/: fsl_sd.c fsl_sdmmc_common.c
  group USB
    ../../user/bsp/usb/host/: usb_host_devices.c usb_host_ehci.c usb_host_framework.c usb_host_hci.c
    ../../user/bsp/usb/host/class/: usb_host_hid.c usb_host_hub.c usb_host_hub_app.c
    ../../user/bsp/usb/osa/: usb_osa_bm.c
    ../../user/bsp/usb/phy/: usb_phy.c
    ../../user/bsp/host_mouse/: app.c host_mouse.c
  group Lwip
    ../../user/bsp/lwip/contrib/apps/ping/: ping.c
    ../../user/bsp/lwip/port/: ethernetif.c sys_arch.c
    ../../user/bsp/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../user/bsp/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../user/bsp/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../user/bsp/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../user/bsp/lwip/src/netif/: ethernet.c lowpan6.c slipif.c
    ../../user/bsp/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
target lcd_flexspi_nor_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.srec"  "#L"
  AfterMake: fromelf.exe --bincombined  --output  "$L@L.bin"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1, USB_STACK_BM
  c misc: as above
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\user\bsp\sdcard\inc;..\..\user\bsp\sdcard\port;..\..\user\bsp\usb\include;..\..\user\bsp\usb\osa;..\..\user\bsp\usb\phy;..\..\user\bsp\usb\host;..\..\user\bsp\usb\host\class;..\..\user\bsp\host_mouse;..\..\user\bsp\lwip\port;..\..\user\bsp\lwip\src;..\..\user\bsp\lwip\src\include;..\..\user\bsp\lwip\contrib\apps;..\..\user\bsp\lwip\test
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
target lcd_flexspi_nor_release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)

# IAR project YH-RT1052.ewp, settings and files
configuration itcm_txt_ram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\libraries; ..\..\libraries\CMSIS\Include; ..\..\libraries\drivers; ..\..\libraries\utilities; ..\..\libraries\utilities\str; ..\..\libraries\utilities\log; ..\..\libraries\utilities\io; ..\..\libraries\xip; ..\..\user; ..\..\user\bsp
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: YH-RT1052.srec
  ILINK.IlinkOutputFile: YH-RT1052.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_itcm_txt_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration itcm_txt_sdram_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_itcm_txt_sdram.icf
configuration sdram_txt_ram_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram_txt_ram.icf
configuration nor_txt_ram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_txt_ram.icf
configuration nor_txt_sdram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_txt_sdram.icf
configuration nor_itcm_txt_ram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; USE_RAM_VECTOR_TABLE
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_itcm_txt_ram .icf
configuration nor_sdram_txt_sdram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_sdram_txt_sdram.icf
  group board
    ../../user/: board.c clock_config.c pin_mux.c
  group CMSIS
    ../../libraries/: system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    ../../doc/: 必读说明.txt
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_common.c fsl_csi.c fsl_elcdif.c fsl_gpio.c fsl_iomuxc.h fsl_lpi2c.c fsl_lpuart.c
    ../../user/bsp/camera/: fsl_csi_camera_adapter.c fsl_sccb.c
  group startup
    ./: startup_MIMXRT1052.s startup_MIMXRT1052_ram_vector.s
  group user
    ../../user/bsp/lcd/: bsp_camera_lcd.c bsp_lcd.c lcd_test.c
    ../../user/bsp/key/: bsp_key.c
    ../../user/bsp/camera/: bsp_ov5640.c bsp_ov5640.h bsp_ov5640_AF.c bsp_ov5640_AF.h bsp_ov5640_config.c
    ../../user/bsp/systick/: bsp_systick.c
    ../../user/bsp/font/: fonts.c
    ../../user/: main.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_sbrk.c fsl_shell.c
    ../../libraries/utilities/io/: fsl_io.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/str/: fsl_str.c
  group xip
    ../../user/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
